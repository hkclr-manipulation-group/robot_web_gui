Commit message: modified:   robot.urdf

File: urdf/arm_v2/robot.urdf (robot description, URDF)
Before this commit: robot arm_v2, 7 links, 6 joints
Joints:
- joint J6: limit lower=-3.141593 upper=3.141593 effort=100 velocity=100 -> lower=-6.2831853 upper=6.2831853 effort=100 velocity=100
